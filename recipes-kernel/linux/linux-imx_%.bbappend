FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://0001-edit-gpio-userspace-dtsi.patch"